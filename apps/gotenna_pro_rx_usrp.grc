options:
  parameters:
    generate_options: qt_gui
    id: gotenna_pro_rx_usrp
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(451.000e6)
  states: {}
- name: dc_block_symbols
  id: variable
  parameters:
    value: '128'
  states: {}
- name: decim
  id: variable
  parameters:
    value: round(16 * (9600 / baud_rate))
  states: {}
- name: fsk_constellation
  id: variable_constellation
  parameters:
    const_points: '[-1.5, -0.5, +1.5, +0.5]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '{2400: 800, 4800: 1500, 9600: 2200}[baud_rate]'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 25000 * (baud_rate / 9600)
    gain: '1.0'
    samp_rate: samp_rate
    width: 15000 * (baud_rate / 9600)
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decim) / (2 * math.pi * fsk_deviation_hz)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: recording.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: round(dc_block_symbols * ((samp_rate / decim) / baud_rate))
    long_form: 'True'
    type: ff
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: fsk_constellation
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: 0.001 * (samp_rate / decim) / baud_rate
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: (samp_rate / decim) / baud_rate
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim
    samp_rate: samp_rate
    taps: lp_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim
    fc: center_freq
    fftsize: '1024'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '4096'
    srate: baud_rate
    style1: '0'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate / decim
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: center_freq
    fftsize: '1024'
    gui_hint: (1,1)
    type: complex
    update_time: '0.01'
    wintype: window.WIN_FLATTOP
  states: {}
- name: tenna_gotenna_decoder_0
  id: tenna_gotenna_decoder
  parameters:
    mode: '1'
  states: {}
- name: tenna_pdu_to_pcapng_0
  id: tenna_pdu_to_pcapng
  parameters:
    append: 'True'
    filename: gotenna_pro.pcapng
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq - offset
    gain0: '5'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_float_to_complex_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_repack_bits_bb_0, '0', tenna_gotenna_decoder_0, '0']
- [dc_blocker_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_float_to_complex_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [tenna_gotenna_decoder_0, pdu, tenna_pdu_to_pcapng_0, pdu]
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
