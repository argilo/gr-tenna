options:
  parameters:
    generate_options: no_gui
    id: gotenna_rx_hackrf
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: chan_spacing
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '75000'
    gain: '1.0'
    samp_rate: chan_spacing
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: chan_spacing // 2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: chan_spacing * 2
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: chan_spacing/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_rate // chan_spacing
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'False'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.5'
    loop_bw: '0.05'
    max_dev: 0.001 * float(chan_spacing) / baud_rate / 4
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: float(chan_spacing) / baud_rate / 4
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: '1'
    samp_rate: chan_spacing
    taps: lp_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: '28000000'
    center_freq: center_freq - offset
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tenna_gotenna_decoder_0
  id: tenna_gotenna_decoder
  parameters:
    mode: '0'
  states: {}
- name: tenna_pdu_to_pcapng_0
  id: tenna_pdu_to_pcapng
  parameters:
    append: 'True'
    filename: gotenna.pcapng
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', tenna_gotenna_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_hackrf_source_0, '0', blocks_keep_one_in_n_0, '0']
- [tenna_gotenna_decoder_0, pdu, tenna_pdu_to_pcapng_0, pdu]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
