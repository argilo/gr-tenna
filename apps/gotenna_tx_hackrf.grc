options:
  parameters:
    generate_options: no_gui
    id: gotenna_tx_hackrf
    output_language: python
    run_options: run
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '926250000'
  states: {}
- name: control_chan
  id: variable
  parameters:
    value: '2'
  states: {}
- name: data_chan
  id: variable
  parameters:
    value: '2'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '20'
  states: {}
- name: packets
  id: variable
  parameters:
    value: gotenna_packet.encode_packets(2, gotenna_packet.encode_encrypted_payload(app_id, 93100711244021, 93100712457340, 1, bytearray(a^b for a,b in zip([0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 4, 0, 0, 0, 0, 0, 0, 193, 198], [0xae, 0x95, 0x6c, 0x00, 0xd2, 0x8b, 0x02, 0x12, 0x5b, 0x1b, 0xa3, 0x88, 0xfc, 0xb8, 0x5a, 0x31, 0xe2, 0x7f, 0xe7]))))
  states: {state: disabled}
- name: packets
  id: variable
  parameters:
    value: gotenna_packet.encode_shout_packets(data_chan, app_id, sender_gid, initials, message)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: silence_time
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: app_id
  id: parameter
  parameters:
    label: App ID
    type: intx
    value: '0x3fff'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: 8 * samp_per_sym
    type: complex
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: 8 * samp_per_sym * interp
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '0.9'
    samp_rate: baud_rate * samp_per_sym * interp
    sensitivity: 2*math.pi
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[0]*silence_time+gotenna_packet.gfsk_bytes(packets)+[0]*silence_time'
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: '[0]*silence_time+gotenna_packet.envelope(packets)+[0]*silence_time'
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: '[0]*silence_time+gotenna_packet.vco(center_freq, control_chan, data_chan, packets)+[0]*silence_time'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: samp_per_sym
    sensitivity: '1.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gotenna_packet
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: initials
  id: parameter
  parameters:
    label: Sender initials
    type: str
    value: VE3IRR
  states: {}
- name: message
  id: parameter
  parameters:
    label: Message
    type: str
    value: Hello world!
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: baud_rate * samp_per_sym * interp
    interp: samp_rate
    type: ccc
  states: {}
- name: sender_gid
  id: parameter
  parameters:
    label: Sender GID
    type: intx
    value: '1234567890'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
    vga: '24'
  states: {}

connections:
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_1, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '1']
- [blocks_repeat_1, '0', blocks_vco_c_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_1, '1']
- [blocks_vector_source_x_0, '0', digital_gfsk_mod_0, '0']
- [blocks_vector_source_x_1, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_2, '0', blocks_repeat_1, '0']
- [digital_gfsk_mod_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_1, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
