options:
  parameters:
    generate_options: no_gui
    id: gotenna_rx_usrp
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: chan_spacing
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: chan_spacing/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_rate // chan_spacing
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.5'
    loop_bw: '0.05'
    max_dev: 0.001 * float(chan_spacing) / baud_rate / 4
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: float(chan_spacing) / baud_rate / 4
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: ff
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: tenna_gotenna_decoder_0
  id: tenna_gotenna_decoder
  parameters:
    mode: '0'
  states: {}
- name: tenna_pdu_to_pcapng_0
  id: tenna_pdu_to_pcapng
  parameters:
    append: 'True'
    filename: gotenna.pcapng
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: '915000000'
    clock_rate: '0.0'
    gain0: '5'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_keep_one_in_n_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_binary_slicer_fb_0, '0', tenna_gotenna_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [tenna_gotenna_decoder_0, pdu, tenna_pdu_to_pcapng_0, pdu]
- [uhd_usrp_source_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
