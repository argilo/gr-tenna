<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gotenna_rx_usrp</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>24000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_spacing</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>12500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000000</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>chan_spacing/(2*math.pi*fsk_deviation_hz)</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>samp_rate / chan_spacing</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.5</value></param>
<param><key>ted_gain</key><value>1.0</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>0.05</value></param>
<param><key>max_dev</key><value>0.001 * float(chan_spacing) / baud_rate / 4</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>float(chan_spacing) / baud_rate / 4</value></param>
<param><key>ted_type</key><value>digital.TED_DANDREA_AND_MENGALI_GEN_MSK</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>gotenna_sink</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr
import gotenna_packet


class blk(gr.sync_block):
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):
        gr.sync_block.__init__(
            self,
            name="Gotenna decoder",
            in_sig=[np.int8],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.prefix = "10"*16 + "0010110111010100"
        self.bits = ""

    def work(self, input_items, output_items):
        self.bits += "".join([str(n) for n in input_items[0]])

        idx = self.bits[:-2048].find(self.prefix)
        while idx &gt;= 0:
            self.bits = self.bits[idx + len(self.prefix):]
            length = int(self.bits[0:8], 2)

            packet = bytearray()
            for i in range(length + 1):
                packet.append(int(self.bits[i*8:i*8 + 8], 2))
            try:
                print
                print "Raw bytes: " + " ".join(["{0:02x}".format(b) for b in packet])

                packet = gotenna_packet.correct_packet(packet)
                print "Corrected: " + " ".join(["{0:02x}".format(b) for b in packet])
                print
                gotenna_packet.decode_tlvs(packet[3:])
            except Exception as err:
                print "Error decoding packet: " + str(err)

            self.bits = self.bits[(length + 1) * 8:]
            idx = self.bits[:-2048].find(self.prefix)

        self.bits = self.bits[-2048 - len(self.prefix) + 1:]
        return len(input_items[0])
</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>915000000</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>5</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>"recv_frame_size=8192,num_recv_frames=128"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>gotenna_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
