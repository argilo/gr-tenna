options:
  parameters:
    generate_options: no_gui
    id: gotenna_rx_hackrf
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: chan_spacing
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '75000'
    gain: '1.0'
    samp_rate: chan_spacing
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: chan_spacing // 2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: chan_spacing * 2
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: chan_spacing/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_rate // chan_spacing
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'False'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.5'
    loop_bw: '0.05'
    max_dev: 0.001 * float(chan_spacing) / baud_rate / 4
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: float(chan_spacing) / baud_rate / 4
    ted_gain: '1.0'
    ted_type: digital.TED_MENGALI_AND_DANDREA_GMSK
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: '1'
    samp_rate: chan_spacing
    taps: lp_taps
    type: ccc
  states: {}
- name: gotenna_sink
  id: epy_block
  parameters:
    _source_code: |
      from __future__ import print_function
      import numpy as np
      from gnuradio import gr
      import gotenna_packet


      class blk(gr.sync_block):
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Gotenna decoder",
                  in_sig=[np.int8],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.prefix = "10"*16 + "0010110111010100"
              self.bits = ""

          def work(self, input_items, output_items):
              self.bits += "".join([str(n) for n in input_items[0]])

              idx = self.bits[:-2048].find(self.prefix)
              while idx >= 0:
                  self.bits = self.bits[idx + len(self.prefix):]
                  length = int(self.bits[0:8], 2)

                  packet = bytearray()
                  for i in range(length + 1):
                      packet.append(int(self.bits[i*8:i*8 + 8], 2))
                  try:
                      print()
                      print("Raw bytes: " + " ".join(["{0:02x}".format(b) for b in packet]))

                      packet = gotenna_packet.correct_packet(packet)
                      print("Corrected: " + " ".join(["{0:02x}".format(b) for b in packet]))
                      print()
                      gotenna_packet.ingest_packet(packet)
                  except Exception as err:
                      print("Error decoding packet: " + str(err))

                  self.bits = self.bits[(length + 1) * 8:]
                  idx = self.bits[:-2048].find(self.prefix)

              self.bits = self.bits[-2048 - len(self.prefix) + 1:]
              return len(input_items[0])
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: '28000000'
    center_freq: center_freq - offset
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', gotenna_sink, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_hackrf_source_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0-rc1
