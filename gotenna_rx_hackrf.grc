options:
  parameters:
    generate_options: no_gui
    id: gotenna_rx_hackrf
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: chan_spacing
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: chan_spacing/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '512'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.5'
    loop_bw: '0.05'
    max_dev: 0.001 * float(chan_spacing) / baud_rate / 4
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: float(chan_spacing) / baud_rate / 4
    ted_gain: '1.0'
    ted_type: digital.TED_DANDREA_AND_MENGALI_GEN_MSK
    type: ff
  states: {}
- name: gotenna_sink
  id: epy_block
  parameters:
    _source_code: |
      from __future__ import print_function
      import numpy as np
      from gnuradio import gr
      import gotenna_packet


      class blk(gr.sync_block):
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Gotenna decoder",
                  in_sig=[np.int8],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.prefix = "10"*16 + "0010110111010100"
              self.bits = ""

          def work(self, input_items, output_items):
              self.bits += "".join([str(n) for n in input_items[0]])

              idx = self.bits[:-2048].find(self.prefix)
              while idx >= 0:
                  self.bits = self.bits[idx + len(self.prefix):]
                  length = int(self.bits[0:8], 2)

                  packet = bytearray()
                  for i in range(length + 1):
                      packet.append(int(self.bits[i*8:i*8 + 8], 2))
                  try:
                      print()
                      print("Raw bytes: " + " ".join(["{0:02x}".format(b) for b in packet]))

                      packet = gotenna_packet.correct_packet(packet)
                      print("Corrected: " + " ".join(["{0:02x}".format(b) for b in packet]))
                      print()
                      gotenna_packet.decode_tlvs(packet[3:])
                  except Exception as err:
                      print("Error decoding packet: " + str(err))

                  self.bits = self.bits[(length + 1) * 8:]
                  idx = self.bits[:-2048].find(self.prefix)

              self.bits = self.bits[-2048 - len(self.prefix) + 1:]
              return len(input_items[0])
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '1'
    bw0: '26000000'
    freq0: '915000000'
    gain0: '1'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', gotenna_sink, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
